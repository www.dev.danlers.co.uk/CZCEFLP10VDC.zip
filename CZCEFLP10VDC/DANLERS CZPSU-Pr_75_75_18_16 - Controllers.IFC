Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: DANLERS CZPSU-Pr_75_75_18_16 - Controllers.IFC
Time: 2016-04-14T11:52:25
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: CZPSU-2 Way Terminal Block (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_18_16; UniClass2 Title: Controllers

# IfcBuildingElementProxy: CZPSU-Connector
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_18_16; UniClass2 Title: Controllers

# IfcBuildingElementProxy: CZPSU-PCB
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_18_16; UniClass2 Title: Controllers

# IfcBuildingElementProxy: CZPSU-Relay Case Bottom
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_18_16; UniClass2 Title: Controllers
PSet_Mass_Property - Mass Measure: 0.0567765; Area Measure: 0.0564564 m2; Volume Measure: 0.0000455094 m3

# IfcBuildingElementProxy: CZPSU-Relay Case Top
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_18_16; UniClass2 Title: Controllers

# IfcBuildingElementProxy: CZPSU-Terminal Cover
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_18_16; UniClass2 Title: Controllers
