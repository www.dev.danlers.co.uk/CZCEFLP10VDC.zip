Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: DANLERS CZPIR-Pr_75_75_76_61 - Passive Infrared Sensors.IFC
Time: 2016-04-14T11:01:39
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: CZPIR-Can
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors
PSet_Mass_Property - Mass Measure: 47211410; Area Measure: 133762115 m2; Volume Measure: 47211406825 m3

# IfcBuildingElementProxy: CZPIR-Can Lid
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: CZPIR-LED
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: CZPIR-Lens
In: Default Storey
PredefinedType: ELEMENT; Material: PE High Density Film
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: CZPIR-Terminal Cover
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: Revolve1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: Revolve2
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors
